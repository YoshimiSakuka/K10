# IAR project TFT32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TFT32.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: common\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    common/: assert.c assert.h crt0.s main.c MK60N512VMD100.h SONYCCD.c
    ./: K60_datatype.h
  group ADC
    common/: ADC.c ADC.h
  group CCDH
    common/: CCDH.c CCDH.h
  group CCDQ
    common/: CCDQ.c CCDQ.h
  group CLOCK
    common/: CLOCK.c CLOCK.h
  group Flash
    common/: Flash.c Flash.h
  group FTM
    common/: FTM.c FTM.h
  group GPIO
    common/: GPIO.c GPIO.h gpio_cfg.h
  group HardWare/Balance
    common/: Balance.c Balance.h
  group HardWare/mma8451
    common/: mma8451.c mma8451.h
  group HardWare/Oled
    common/: Oled.c Oled.h
  group I2C
    common/: i2c.c i2c.h
  group ISR
    common/: isr.c isr.h vectors.c
  group PIT
    common/: PIT.c PIT.h vectors.h
  group UART
    common/: _printf.c _printf.h
  group union_control
    common/: union_control.c union_control.h
