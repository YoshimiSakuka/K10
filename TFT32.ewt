<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>ADC</name>
    <file>
      <name>$PROJ_DIR$\common\ADC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\ADC.h</name>
    </file>
  </group>
  <group>
    <name>CCDH</name>
    <file>
      <name>$PROJ_DIR$\common\CCDH.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\CCDH.h</name>
    </file>
  </group>
  <group>
    <name>CCDQ</name>
    <file>
      <name>$PROJ_DIR$\common\CCDQ.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\CCDQ.h</name>
    </file>
  </group>
  <group>
    <name>CLOCK</name>
    <file>
      <name>$PROJ_DIR$\common\CLOCK.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\CLOCK.h</name>
    </file>
  </group>
  <group>
    <name>Flash</name>
    <file>
      <name>$PROJ_DIR$\common\Flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\Flash.h</name>
    </file>
  </group>
  <group>
    <name>FTM</name>
    <file>
      <name>$PROJ_DIR$\common\FTM.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\FTM.h</name>
    </file>
  </group>
  <group>
    <name>GPIO</name>
    <file>
      <name>$PROJ_DIR$\common\GPIO.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\GPIO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\gpio_cfg.h</name>
    </file>
  </group>
  <group>
    <name>HardWare</name>
    <group>
      <name>Balance</name>
      <file>
        <name>$PROJ_DIR$\common\Balance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\common\Balance.h</name>
      </file>
    </group>
    <group>
      <name>mma8451</name>
      <file>
        <name>$PROJ_DIR$\common\mma8451.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\common\mma8451.h</name>
      </file>
    </group>
    <group>
      <name>Oled</name>
      <file>
        <name>$PROJ_DIR$\common\Oled.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\common\Oled.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>I2C</name>
    <file>
      <name>$PROJ_DIR$\common\i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\i2c.h</name>
    </file>
  </group>
  <group>
    <name>ISR</name>
    <file>
      <name>$PROJ_DIR$\common\isr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\isr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\vectors.c</name>
    </file>
  </group>
  <group>
    <name>PIT</name>
    <file>
      <name>$PROJ_DIR$\common\PIT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\PIT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\vectors.h</name>
    </file>
  </group>
  <group>
    <name>UART</name>
    <file>
      <name>$PROJ_DIR$\common\_printf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\_printf.h</name>
    </file>
  </group>
  <group>
    <name>union_control</name>
    <file>
      <name>$PROJ_DIR$\common\union_control.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\common\union_control.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\common\assert.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\common\assert.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\common\crt0.s</name>
  </file>
  <file>
    <name>$PROJ_DIR$\K60_datatype.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\common\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\common\MK60N512VMD100.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\common\SONYCCD.c</name>
  </file>
</project>


